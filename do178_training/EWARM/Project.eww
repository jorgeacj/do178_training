<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\do178_training.ewp</path>
  </project>
  <batchBuild />
</workspace>
